# Keil uVision project 7.2定时器时钟.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 7.2定时器时钟
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51 main2
    ../5.2lcd1602调试工具/LCD1602驱动代码/: LCD1602.c LCD1602.h
