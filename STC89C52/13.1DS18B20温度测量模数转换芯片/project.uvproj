# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../12.1XPT2046/: delay.c delay.h LCD1602.c LCD1602.h
    ./: STARTUP.A51 mian.c DS18B20.c DS18B20.h OneWire.c OneWire.h Timer0.c Timer0.h
    ../11.1蜂鸣器播放提示音/: Nixie.c Nixie.h
